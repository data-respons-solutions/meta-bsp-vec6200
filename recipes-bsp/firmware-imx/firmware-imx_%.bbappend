COMPATIBLE_MACHINE = "(imx|use-mainline-bsp)"